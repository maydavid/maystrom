# Repository maydavid/maystrom

File README.md:

# maystrøm

open modular camper automation system

## bc1

**bus control:**  

This is the main controller. It is used for interacting with the user, controlling actuators, reading sensors, power management and so on. Right now it is build around a FRDM-KL46Z board with a Cortex-M0+ running at 48 MHz. It's firmware is developed using the mbed SDK.

The current *breadboard* prototype consists of:
  * NHD-24-320240 TFT to display data
  * RedBearLab BLE mini to allow for control and sensing via BLE enabled smartphones
  * Rotary encoder for user interaction

## bp1

**bus power:**

Used for switching and sensing the main 12V input. Furthermore it generates the 3.3V used for the uC and the the onboard current sensor. The main 12V rail is switched with a relay controlled by the µC on the **bc** module. The current flowing to the loads is sensed using a ACS711. The voltage cn be senses with the help of a simple voltage divider. 

## cm1

**control module:**  

This module is capable of switching and dimming high voltage loads. Multiple of these can be connected to **bc1** and **bp1**. The modules have a pwm input that allows to to dim lights for instance. The modules can be equipped with a voltage regulator to ensure a steady 12V output even at engine startup or while driving. If not needed (usually the case for automotive accessories) they can be bypassed with a solder bridge.

## EAGLE design hardware/bp1/bp1.brd

Parts:
3V_LED, 12V_LED: M02JST-PTH-2; JST-2-PTH
3V_REG_IN, 3V_REG_OUT, 12V_CON, 12V_TERMINAL: M025MM; SCREWTERMINAL-5MM-2
ACS711: ACS712; SO08
C1: 1nF; CAP-PTH-SMALL-KIT
C2: 0.1uF; CAP-PTH-SMALL-KIT
D1, D2: 1N4004; DO41-10
D3: 1N4148DO35-7; DO35-7
F3: FUSEX20MM; FUSE_5MM
JP1, JP2: M04POLAR; MOLEX-1X4
M1, M2, M3, M4: MOUNT-HOLE3.0; 3,0
POWER_PB: M02JST-PTH-2; JST-2-PTH
Q3: 2N3904; TO92
Q4: BC560; TO92-EBC
R1, R4: 1k; AXIAL-0.4
R2, R9: 10k; AXIAL-0.4
R3, R6: 470; AXIAL-0.4
R5: 100; AXIAL-0.4
R7, R10: 2.2k; AXIAL-0.4
R8: 820; AXIAL-0.4
U$1: RELAYPTH3; RELAY-T9A-2

Connections:
3V: 3V_REG_IN.1, ACS711.8 (VCC), C2.1, JP1.4, R1.P$2 (2), R5.P$1 (1)
12V_MAIN: F3.3 (2), POWER_PB.1, Q4.E, U$1.MAIN
12V_SW: ACS711.1 (IP+), ACS711.2 (IP+), R2.P$2 (2), R8.P$1 (1), U$1.NO
12V_SW_OUT: 3V_REG_OUT.1, 12V_TERMINAL.1, ACS711.3 (IP-), ACS711.4 (IP-)
#FAULT: ACS711.6 (FILT), JP2.2, R1.P$1 (1)
GND: 3V_LED.1, 3V_REG_IN.2, 3V_REG_OUT.2, 12V_CON.2, 12V_LED.1, 12V_TERMINAL.2, ACS711.5 (GND), C1.2, C2.2, D3.A, JP1.3, Q3.3 (E), R6.P$1 (1), R7.P$1 (1), R10.P$1 (1), U$1.COIL2
unnamed: 12V_LED.2, R8.P$2 (2)
unnamed: 12V_CON.1, F3.1
unnamed: Q3.1 (C), R4.P$1 (1)
unnamed: Q4.B, R4.P$2 (2)
unnamed: Q3.2 (B), R3.P$2 (2)
unnamed: D1.A, Q4.C
unnamed: D1.C, D2.C, D3.C, R6.P$2 (2), U$1.COIL1
unnamed: 3V_LED.2, R5.P$2 (2)
POWER_PB: D2.A, POWER_PB.2, R9.P$2 (2)
POWER_SW_PB: JP1.1, R9.P$1 (1), R10.P$2 (2)
PWR_ON_UC: JP1.2, R3.P$1 (1)
VOUT: ACS711.7 (VOUT), C1.1, JP2.4
VSENSE: JP2.3, R2.P$1 (1), R7.P$2 (2)

Board: 4 copper layers, 73.3 x 63.5 mm, 33 parts (0 on the bottom side), 19 nets.

## EAGLE design hardware/cm1/cm1.brd

Parts:
12V_OUT, 12_IN: M025MM; SCREWTERMINAL-5MM-2
C1: CPOL7343
C2: 3.3u/100V; CAP-PTH-SMALL
CTRL: M02JST-PTH-2; JST-2-PTH
D2: 1N5819-B; DO41-7.6
F2: FUSEX20MM; FUSE_5MM
IRF4905: PMOSFET_PTO220BV; TO220BV
LM2940-12: V_REG_317SINK; TO220-ADJ
Q3: 2N3904; TO92
R1, R2: 1k5; AXIAL-0.4
SJ1: SOLDERJUMPERPTH; SJ_2S-PTH
STANDOFF1, STANDOFF2: STAND-OFF

Connections:
12V_SW: 12_IN.2, C2.1, LM2940-12.IN, SJ1.1
GND: 12V_OUT.2, 12_IN.1, C1.-, C2.2, CTRL.1, LM2940-12.ADJ, Q3.3 (E)
unnamed: D2.A, F2.1, IRF4905.D
unnamed: CTRL.2, R1.P$2 (2)
unnamed: 12V_OUT.1, F2.3 (2)
unnamed: Q3.2 (B), R1.P$1 (1)
unnamed: IRF4905.G, Q3.1 (C), R2.P$1 (1)
unnamed: C1.+, D2.C, IRF4905.S, LM2940-12.OUT, R2.P$2 (2), SJ1.2

Board: 4 copper layers, 35.2 x 48.2 mm, 15 parts (0 on the bottom side), 8 nets.

## Commit log

2014-01-13 initial structure
2014-05-01 modifed readme
2014-05-01 removed empty software folders
2014-05-01 inital rev of cm1 (untested)
2014-05-17 removed pull up transistor from cm1
2014-06-04 fixed wrong transistor
2014-06-04 added gerber files
2014-06-06 initial bp1 schematics commit
2014-06-06 changed path
2014-10-16 initial mbed project
2014-10-16 notification hal implemented
2014-10-19 communication hal
2014-10-19 promotion hal
2014-10-19 config hal
2014-10-19 aqusition hal
2014-10-19 added structure of main programm flow
2014-10-19 disabled lcd for faster testing
2014-10-19 minor

Notices in the files:
parts and their libraries:
SparkFun-Passives: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
